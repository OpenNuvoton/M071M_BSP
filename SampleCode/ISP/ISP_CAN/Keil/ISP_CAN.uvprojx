# Keil uVision project ISP_CAN.uvprojx, settings and files
target ISP_CAN (6120000::V6.12::.\ARMCLANG)
  device: M071MD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: ISP_CAN
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M071M\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --map --first='startup_M071M.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071M/Source/: system_M071M.c
    ../../../../Library/Device/Nuvoton/M071M/Source/ARM/: startup_M071M.s
  group Library
    ../../../../Library/StdDriver/src/: can.c fmc.c clk.c
  group User
    ../: main.c
