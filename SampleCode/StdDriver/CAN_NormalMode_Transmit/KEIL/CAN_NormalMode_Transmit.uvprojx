# Keil uVision project CAN_NormalMode_Transmit.uvprojx, settings and files
target CAN_NormalMode_Transmit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M071MD2AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(CLOCK(50000000)) CPUTYPE("Cortex-M0")
  output: CAN_NormalMode_Transmit
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M071M\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M071M.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/Device/Nuvoton/M071M/Source/: system_M071M.c
    ../../../../Library/Device/Nuvoton/M071M/Source/ARM/: startup_M071M.s
  group Source files
    ../: main.c
  group Library files
    ../../../../Library/StdDriver/src/: retarget.c clk.c sys.c uart.c can.c
