# IAR project TIMER_Delay.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071M series Nuvoton M071M series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M071M\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TIMER_Delay.bin
  ILINK.IlinkOutputFile: TIMER_Delay.out
  ILINK.IlinkIcfFile: TIMER_Delay.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071M/Source/IAR/: startup_M071M.s
    ../../../../Library/Device/Nuvoton/M071M/Source/: system_M071M.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sys.c timer.c uart.c
  group User
    ../: main.c
