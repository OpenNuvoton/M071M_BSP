# IAR project fmc_ap_main.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071M series Nuvoton M071M series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\M071M\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: fmc_ap_main.bin
  ILINK.IlinkOutputFile: APROM_code.out
  ILINK.IlinkIcfFile: fmc_ap_main.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\fmc_ld_iap.bin,loaderImage1Base,.bin_image,4; --image_input Release\Exe\fmc_ld_iap.bin,loaderImage1Limit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071M/Source/IAR/: startup_M071M.s
    ../../../../Library/Device/Nuvoton/M071M/Source/: system_M071M.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c retarget.c sys.c uart.c
  group User
    ../: APROM_main.c
