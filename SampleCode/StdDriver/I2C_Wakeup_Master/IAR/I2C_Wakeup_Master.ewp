# IAR project I2C_Wakeup_Master.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M071M series Nuvoton M071M series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\Library\Device\Nuvoton\M071M\Include; ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Wakeup_Master.bin
  ILINK.IlinkOutputFile: I2C_Wakeup_Master.out
  ILINK.IlinkIcfFile: I2C_Wakeup_Master.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M071M/Source/IAR/: startup_M071M.s
    ../../../../Library/Device/Nuvoton/M071M/Source/: system_M071M.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c i2c.c retarget.c sys.c uart.c
  group User
    ../: main.c
